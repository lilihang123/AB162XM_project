/* SPDX-License-Identifier: Apache-2.0 */

#include <airoha/ab162x/flash_partitions/single_slot_2MB_with_ECDSA_OTA.dtsi>

/ {
    chosen {
        zephyr,code-partition = &boot_partition;
    };
};
